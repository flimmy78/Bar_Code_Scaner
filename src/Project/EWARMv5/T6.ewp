# IAR project T6.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: ..\; ..\..\App\; ..\..\Drivers\; ..\..\FatFs\; ..\..\Lib\inc\; ..\..\uCOS\uC-CPU\; ..\..\uCOS\uC-LIB\; ..\..\uCOS\uCOS-II\Ports\; ..\..\uCOS\uCOS-II\Source\; ..\..\uCOS\uC-Probe\; ..\..\usb_lib\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: T6.bin
  ILINK.IlinkOutputFile: T6.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cortexm3_macro.s stm32f10x_vector.c
    ../: main.c stm32f10x_it.c
  group App
    ../../App/: app.c basic_fun.c data_transfer.c des.c dialog.c dummy_fat16_data.c edit.c gui.c hash.c JMemory.c PCUsart.c record.c res_spi.c Terminal_Para.c tlv.c
  group Drivers
    ../../Drivers/: calendar.c crc32.c data_uart.c keypad.c lcd.c power_detect.c sd2068.c spi_flash.c TimeBase.c uart_drv.c uE988_scan.c YFBT07.c
  group FatFs
    ../../FatFs/: diskio.c ff.c
  group FWLib
    ../../Lib/src/: hardfault_isr_handle_a.asm stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group uCOS
    ../../uCOS/uC-CPU/: cpu_a.asm cpu_c.c
    ../../uCOS/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
    ../../uCOS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../uCOS/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../../uCOS/uC-Probe/: os_probe.c
  group USB
    ../../usb_lib/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_scsi.c usb_sil.c
